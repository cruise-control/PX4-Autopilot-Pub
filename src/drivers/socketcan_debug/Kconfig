## src/drivers/socketcan_debug/Kconfig
```kconfig
menuconfig DRIVERS_SOCKETCAN_DEBUG
	bool "socket_can_debug"
	default n
	---help---
		Enable support for socket_can_debug
```
